# Keil uVision project mdk-proj.uvprojx, settings and files
target mdk-proj (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: mdk-proj
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../lab-src/lab
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group New Group
    ../../lab-src/lab/kern/: app_fsm4.c bitops.h board.h board_cm.h board_fsm4.c board_itm.c board_qemu.c critical.h debug.c debug.h fifo.h heap.c heap.h ios_device.c ios_device.h ios_fd.c ios_fd.h kern_api.h kern_config.h kern_def.h kern_init.c kern_port.h kern_port_cm3.c kern_port_cm3_ccarm.c kern_port_cm3_gnu.c kern_test.c kshell.c kshell.h kshell_cmd.c ktest.c ktest.h msgq.c msgq_api.h mutex.c mutex_api.h pipe.c pipe_api.h queue.h semaphore.c semaphore_api.h task.c task_api.h timer.c timer_api.h
    ../../lab-src/lab/project1/: project1_main.c syscall.c syscall.h syscall_ccarm.S
    ../../lab-src/lab/project2/: button.h button_scan.c gpio_ops.c project2_main.c
    ../../lab-src/lab/project3/: kfifo.c kfifo.h project3_main.c
    ../../lab-src/lab/project4/: beep.c beep.h button.c decode.c decode.h key.c key.h led.c led.h pin.h pin_device.c pin_driver.c player.c player.h project4_main.c pwm.h pwm_device.c pwm_driver.c song_data.h
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c
software components: CMSIS:CORE 4.1.0
